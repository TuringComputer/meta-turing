PNBLACKLIST[wvdial] = ""