MIRRORS += "http://archive.apache.org/dist/httpd/httpd-${PV}.tar.bz2"
