FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0002-chromium-Change-false-to-FALSE-and-1-to-TRUE-FIX-qtw.patch"

