PACKAGECONFIG_append = " accessibility"

